# Keil uVision project LED.uvproj, settings and files
target gsensor_stm32 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: LED +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F0XX_LD,
  c include: ..\ST_Lib\incs;..\ST_Lib\inc;..\ST_Lib\src;..\System\CMSIS;..\System\startup;..\User;..\My_Lib\delay;..\My_Lib\LED;..\My_Lib\lis3dh;..\ST_Lib\Communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../User/: main.c example_main.c
  group ST_Lib
    ../System/CMSIS/: stm32f0xx_conf.h stm32f0xx.h
    ../ST_Lib/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_usart.c stm32f0xx_exti.c stm32f0xx_i2c.c stm32f0xx_misc.c stm32f0xx_syscfg.c
  group My_Lib
    ../ST_Lib/Communication/: spi_mems.h spi_mems.c stm320518_eval.c
    ../My_Lib/LED/: led.c
    ../My_Lib/delay/: delay.c
    ../My_Lib/lis3dh/: lis3dh_driver.c
  group System
    ../System/CMSIS/: system_stm32f0xx.h core_cm0.h core_cm0plus.h system_stm32f0xx.c
    ../System/startup/: startup_stm32f0xx_ld.s
